# Keil uVision project Project.uvproj, settings and files
target Open407-D (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\FatFS;..\User\UDA1380
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c config.h usart.c sdcard.c stm32f4xx_it.c
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c misc.c stm32f4xx_i2c.c stm32f4xx_spi.c
  group CMSIS
    ../Libraries/CMSIS/Include/: core_cm4.h
    ../User/: system_stm32f4xx.c
  group Readme
    ../User/: readme.txt
  group FatFS
    ../Libraries/FatFS/: diskio.c ff.c
  group UDA1380
    ../User/UDA1380/: I2C.c I2S.c UDA1380.c
