# IAR project Project.ewp, settings and files
configuration BOOT_FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10x ST STM32F10x
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ; ..\include; ..\..\FWLib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
configuration BOOT_RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_RAM
  ICCARM.CCIncludePath2: ; ..\include; ..\..\..\FWLib\inc
  XLINK.XclFile: lnkarm_ram.xcl
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../FWLib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../source/: lcd.c main.c stm32f10x_encoder.c stm32f10x_it.c stm32f10x_Timebase.c
