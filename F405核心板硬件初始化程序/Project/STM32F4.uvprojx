# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\Mylib;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group Mylib
    ../Mylib/: ad.c led.c buzzer.c delay.c pwm.c timer.c usart2.c usart3.c oled.c key.c encoder.c can1.c
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c startup_stm32f4xx.s
software components: CMSIS:CORE 4.3.0
